# Keil uVision project F4_GPIO.uvproj, settings and files
target Source (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: exec
  c flags: Optim=4 oTime=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX,ARM_MATH_CM4,__FPU_PRESENT
  c include: .\STM32F4_Discovery;.\lib_sys\inc;.\Source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK_ARM
    ./MDK_ARM/: startup_stm32f4xx.s
  group Includes
    ./Source/: Encoder.h main.h PWM.h tm_stm32f4_i2c.h tm_stm32f4_mpu6050.h UART_DMA.h filter.h matrix.h
  group Source
    ./Source/: tm_stm32f4_i2c.c tm_stm32f4_mpu6050.c main.c UART_DMA.c PWM.c Encoder.c filter.c matrix.c
  group STM32F4_StdPeriph
    ./lib_sys/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_i2c.c
  group STM32F4_Discovery
    ./STM32F4_Discovery/: system_stm32f4xx.c
